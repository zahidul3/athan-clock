<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\sensor_2_4g_cc26x2lp.ewp</path>
    </project>
    <batchBuild />
</workspace>

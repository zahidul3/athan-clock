# IAR project sensor_2_4g_cc26x2lp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sensor_2_4g_cc26x2lp.out
configuration Release (ARM)
  as the first configuration, except:
  group (top)
    ./: sensor_2_4g_cc26x2lp.ipcf
  group Configuration files
    ../../../common/boards/CC26X2R1_LAUNCHXL/: app.cfg

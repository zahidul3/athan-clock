# IAR project cc26x2r1lp_app.ewp, settings and files
configuration FlashROM_Release (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: $TARGET_BNAME$.hex
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_release.cfg
  ILINK.IlinkOutputFile: ble5_simple_peripheral_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; PAGE_ALIGN=1; FLASH_ONLY_BUILD=1; ENCRYPTION_ROM=1
  ILINK.IlinkIcfFile: $SRC_BLE_DIR$\common\cc26xx\iar\cc26xx_app_and_stack_agama.icf
  ILINK.IlinkExtraOptions: --keep __vector_table; -f ..\config\configPkg\linker.cmd; -f ..\config\lib_linker.cmd
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1\driverlib\bin\iar\driverlib.lib; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\kernel\tirtos\packages\ti\dpl\lib\dpl_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\lib\drivers_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\drivers\rf\lib\rf_multiMode_cc26x2_v1.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\display\lib\display.arm4f; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\grlib\lib\iar\m4f\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FlashROM_PTM_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt; -f $SRC_BLE_DIR$\config\build_components.opt; -f $SRC_BLE_DIR$\config\factory_config.opt; -f $EXAMPLE_BLE_ROOT$\tirtos\build_config_ptm.opt; -f ..\config\configPkg\compiler.opt.defs
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\rom; $SRC_BLE_DIR$\npi\src\inc; $SRC_BLE_DIR$\npi\src; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
configuration FlashROM_Debug (ARM, debug)
  as the first configuration, except:
  prebuild: "$XDCROOT$\xs" --xdcpath="$XDCPATH$" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$" -o ..\config\configPkg $EXAMPLE_BLE_ROOT$\tirtos\ble_debug.cfg
configuration FlashROM_RCOSC_Release (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $SRC_BLE_DIR$\controller\cc26xx\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\common\cc26xx; $SRC_BLE_DIR$\common\cc26xx\rcosc; $EXAMPLE_BLE_ROOT$\src\app; $SRC_BLE_DIR$\icall\inc; $SRC_BLE_DIR$\inc; $SRC_BLE_DIR$\profiles\dev_info; $SRC_BLE_DIR$\profiles\simple_profile; $SRC_BLE_DIR$\profiles\simple_profile\cc26xx; $SRC_BLE_DIR$\target; $SRC_BLE_DIR$\hal\src\inc; $SRC_BLE_DIR$\hal\src\target\_common; $SRC_BLE_DIR$\hal\src\target\_common\cc26xx; $SRC_BLE_DIR$\hal\src\target\cc2650\rom; $SRC_BLE_DIR$\heapmgr; $SRC_BLE_DIR$\icall\src\inc; $SRC_BLE_DIR$\osal\src\inc; $SRC_BLE_DIR$\services\src\saddr; $SRC_BLE_DIR$\services\src\sdata; $SRC_BLE_DIR$\services\src\nv; $SRC_BLE_DIR$\services\src\nv\cc26xx; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  group Application
    $SRC_BLE_DIR$/common/cc26xx/: board_key.c board_key.h util.c util.h
    $SRC_BLE_DIR$/common/cc26xx/rcosc/: rcosc_calibration.c rcosc_calibration.h
    $EXAMPLE_BLE_ROOT$/src/app/: simple_peripheral.c simple_peripheral.h simple_peripheral_menu.c simple_peripheral_menu.h
    $SRC_BLE_DIR$/common/cc26xx/menu/: two_btn_menu.c two_btn_menu.h
  group Drivers/NV
    $SRC_BLE_DIR$/services/src/nv/cc26xx/: crc.c crc.h nvoctp.c nvoctp.h
  group Drivers/TRNG
    $SRC_BLE_DIR$/hal/src/target/_common/: TRNGCC26XX.c TRNGCC26XX.h
  group ICall
    $SRC_BLE_DIR$/icall/src/: icall.c icall_cc2650.c icall_platform.h icall_user_config.c
    $SRC_BLE_DIR$/icall/src/inc/: icall.h
    $SRC_BLE_DIR$/icall/inc/: icall_addrs.h
  group ICallBLE
    $SRC_BLE_DIR$/icall/app/: ble_user_config.c icall_api_lite.c icall_hci_tl.c
    $SRC_BLE_DIR$/icall/inc/: ble_user_config.h icall_ble_apimsg.h
  group Include
    $SRC_BLE_DIR$/inc/: gap.h gapbondmgr.h gapgattserver.h gatt.h hci.h
    $SRC_BLE_DIR$/osal/src/inc/: osal_snv.h
  group NPI
    $SRC_BLE_DIR$/npi/src/: npi_frame_hci.c npi_rxbuf.c npi_task.c npi_tl.c npi_tl_uart.c
  group Profiles
    $SRC_BLE_DIR$/profiles/dev_info/cc26xx/: devinfoservice.c
    $SRC_BLE_DIR$/profiles/dev_info/: devinfoservice.h
    $SRC_BLE_DIR$/inc/: gatt_profile_uuid.h
    $SRC_BLE_DIR$/host/: gatt_uuid.c gatt_uuid.h gattservapp_util.c
    $SRC_BLE_DIR$/profiles/simple_profile/cc26xx/: simple_gatt_profile.c
    $SRC_BLE_DIR$/profiles/simple_profile/: simple_gatt_profile.h
  group StackLibrary
    ../stack/FlashROM_Library/Exe/: cc26x2r1lp_stack_FlashROM_Library.a
  group Startup
    $SRC_BLE_DIR$/target/: board.c
    $EXAMPLE_BLE_ROOT$/src/: ccfg_app_ble.c
    $SRC_BLE_DIR$/common/cc26xx/rcosc/: ccfg_app_ble_rcosc_agama.c
    $EXAMPLE_BLE_ROOT$/src/app/: main.c
  group Tools
    ../../: ble_debug.cfg ble_release.cfg
    $SRC_BLE_DIR$/common/cc26xx/iar/: cc26xx_app_and_stack_agama.icf
  group Tools/defines
    defines/: cc26x2r1lp_app_FlashROM_Debug.opt cc26x2r1lp_app_FlashROM_RCOSC_Release.opt cc26x2r1lp_app_FlashROM_Release.opt cc26x2r1lp_app_src_FlashROM_PTM_Release.opt

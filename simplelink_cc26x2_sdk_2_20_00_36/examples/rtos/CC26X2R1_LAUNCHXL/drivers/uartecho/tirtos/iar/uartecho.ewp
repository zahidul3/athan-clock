# IAR project uartecho.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -f$SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC26X2R1_LAUNCHXL/release/iar/compiler.opt.defs; -DDeviceFamily_CC26X2; -I$SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source; -I$SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/posix/iar; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  prebuild: iarbuild.exe $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC26X2R1_LAUNCHXL/release/iar/tirtos_builds_CC26X2R1_LAUNCHXL_release.ewp Debug -log all
  ILINK.IlinkOutputFile: uartecho.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC26X2R1_LAUNCHXL_TIRTOS.icf
  ILINK.IlinkExtraOptions: -f$SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC26X2R1_LAUNCHXL/release/iar/linker.cmd; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4f/spiffs_cc26xx.a; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc26x2_v1.arm4f; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc26x2_v1.arm4f; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/drivers/pdm/lib/pdm_cc26x2_v1.arm4f; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/kernel/tirtos/packages/ti/dpl/lib/dpl_cc26x2_v1.arm4f; $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2_v1/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M4F; --redirect; _Printf=_PrintfSmall; --redirect; _Scanf=_ScanfSmall
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group UART Echo/Documentation
    $SIMPLELINK_CC26X2_SDK_INSTALL_DIR$/source/ti/boards/CC26X2R1_LAUNCHXL/: Board.html
    ./: README.html README.md
  group UART Echo/Header files
    ./: Board.h CC26X2R1_LAUNCHXL.h
  group UART Echo/Source files
    ./: CC26X2R1_LAUNCHXL.c CC26X2R1_LAUNCHXL_fxns.c ccfg.c main_tirtos.c uartecho.c uartecho_CC26X2R1_LAUNCHXL_TIRTOS.icf

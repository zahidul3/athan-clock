# IAR project cc26x2r1lp_bim_offchip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DeviceFamily_CC26X2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f defines\$PROJ_FNAME$_$CONFIG_NAME$.opt
  ICCARM.CCIncludePath2: $SRC_COMMON_DIR$; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1; $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cc26x2r1lp_bim_offchip.hex
  ILINK.IlinkOutputFile: sp_oad_offchip_$PROJ_FNAME$_$CONFIG_NAME$.out
  ILINK.IlinkConfigDefines: CC2642=1; xENCRYPTION_ROM=1; xPAGE_ALIGN=1
  ILINK.IlinkIcfFile: $SRC_COMMON_DIR$\cc26xx\iar\bim_cc26x2_cc13x2.icf
  ILINK.IlinkExtraOptions: --keep __vector_table
  ILINK.IlinkAdditionalLibs: $SIMPLELINK_CORE_SDK_INSTALL_DIR$\source\ti\devices\cc13x2_cc26x2_v1\driverlib\bin\iar\driverlib.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2652R1F TexasInstruments CC2652R1F
  group Application
    ../../src/: bim_main.c ccfg_app.c
    $SRC_COMMON_DIR$/cc26xx/bim/: bim_util.c bim_util.h
    $SRC_COMMON_DIR$/cc26xx/crc/: crc32.c crc32.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/: flash_interface.h
    $SRC_COMMON_DIR$/cc26xx/flash_interface/internal/: flash_interface_internal.c
    $SRC_COMMON_DIR$/cc26xx/debug/: led_debug.c led_debug.h
    $SRC_COMMON_DIR$/cc26xx/oad/: oad_image_header.h
    $SIMPLELINK_CORE_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2_v1/startup_files/: startup_iar.c
  group Board
    $SRC_COMMON_DIR$/cc26xx/board_support_pkg/CC26X2R1_CC13X2R1_LAUNCHXL/: bsp.h
  group ExtFlash
    $SRC_COMMON_DIR$/cc26xx/board_support_pkg/CC26X2R1_CC13X2R1_LAUNCHXL/: ext_flash.c ext_flash.h
  group SPI
    $SRC_COMMON_DIR$/cc26xx/board_support_pkg/CC26X2R1_CC13X2R1_LAUNCHXL/: bsp_spi.c bsp_spi.h
  group Tools
    $SRC_COMMON_DIR$/cc26xx/iar/: bim_cc26x2_cc13x2.icf
  group Tools/defines
    defines/: cc26x2r1lp_bim_offchip_Debug.opt cc26x2r1lp_bim_offchip_Release.opt

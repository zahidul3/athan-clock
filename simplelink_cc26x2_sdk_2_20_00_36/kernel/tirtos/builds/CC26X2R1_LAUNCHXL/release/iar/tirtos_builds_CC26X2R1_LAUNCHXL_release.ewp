# IAR project tirtos_builds_CC26X2R1_LAUNCHXL_release.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -DDeviceFamily_CC26X2
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  prebuild: "$XDCROOT$/xs" --xdcpath="$XDCPATH$" iar.tools.configuro -o ../iar -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group TIRTOS kernel project/Configuration files
    ../: release.cfg
  group TIRTOS kernel project/Documentation
    ../: README.html
